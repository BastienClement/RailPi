# Keil uVision project RailHub.uvproj, settings and files
target RailHub (MCS-51)
  device: C8051F020 Silicon Laboratories, Inc.
  cpu: IRAM(0-0xFF) XRAM(0-0xFFF) IROM(0-0xFFFF) CLOCK(25000000)
  output: RailHub
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\shared
  group Source
    ./src/: main.c sys.c
