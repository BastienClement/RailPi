# Keil uVision project railtrain.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F330 Silicon Laboratories, Inc.
  cpu: IRAM(0-0xFF) XRAM(0-0x1FF) IROM(0-0x1FFF) CLOCK(25000000)
  output: railtrain
  c flags: Optimize=9 SizeSpeed=1
  group Source Group 1
    ./: main.c
